# Repository IpinZhu/foc-esc

File README.md:

# STM32G473 三相 FOC 驱动器

这是一个基于 STM32G473RC 的实验性三相 PMSM/BLDC 电机控制平台。仓库包含驱动板设计，以及使用 Rust 2024 + Embassy 实现的电流控制型磁场定向控制（FOC）固件。

> **安全提示：** 这是一个大电流电力电子原型。固件和 PCB 尚未完成生产级电气鉴定或验证。在使用合适的实验设备和限流措施检查栅极波形、死区时间、电流采样极性、ADC 时序、故障响应、绝缘/间距和热性能之前，不要连接电机或电池。

## 当前实现

当前固件位于 [`software/firmware`](software/firmware)，目标芯片为 STM32G473RC：

- TIM1 中心对齐互补 PWM，输出引脚为 PA8/PA9/PA10 和 PB13/PB14/PB15。
- 配置的 PWM 频率：**100 kHz**。
- 配置的死区时间：在 170 MHz 定时器时钟下为 **200 ns**。
- 占空比范围：5%–95%。
- 通过 INA240A2 放大器和 0.5 mΩ 分流电阻进行三相电流反馈。
- 由定时器触发 ADC，对相电流、VBUS 和 TMP235 温度传感器进行采样。
- 支持电流 FOC、速度 FOC、开环控制、启动电流偏置校准、SVPWM、遥测和软件故障处理。
- 带版本和 CRC 的双槽 Flash 参数持久化：上电自动加载，UART `param ...` 命令和 CAN 参数帧可读取、设置、保存或恢复出厂参数。
- 电机参数自整定（Auto-Tune）：`autotune start` 执行 Rs/L/磁链辨识、电流环 PI 计算与阶跃验证、基于转子传感器的开环同步校验和观测器参数配置，结果保存为带 CRC 的电机参数档案，重启后自动应用。观测器/PLL 阶段目前仅生成与校验参数，尚未实现无感角度估算、HFI 或无感闭环接管。
- 编译期选择转子传感器：
  - `sensor-encoder`（默认）：TIM3 正交编码器，连接 PB4/PB5。
  - `sensor-hall`：TIM3 Hall 输入捕获，连接 PC6/PC7/PC8。
- USART3 ASCII 调试命令，连接 PB10/PB11。
- FDCAN1 classic CAN 控制和遥测，连接 PA11/PA12。

当前固件采用**纯软件保护**。本轮没有启用 COMP→DAC→TIM1-BRK 硬件过流链。软件保护包括电流阈值/去抖、相电流残差、母线欠压/过压、模型温度和传感器温度、堵转、传感器有效性以及控制超时处理。软件保护不能替代经过验证的硬件关断路径。

## 系统概览

```text
                    +-----------------------------+
  编码器 / Hall --->|                             |--> TIM1 互补 PWM
  相电流 ---------->|       STM32G473RC           |       (100 kHz, 200 ns)
  VBUS / TMP235 --->|       Rust + Embassy        |--> UCC27211 x3
  UART ------------>|       FOC 控制器            |--> 070N10NS 级三相桥
  FDCAN ----------->|                             |<-- INA240A2 x3 + 分流电阻
                    +-----------------------------+
```

固件将高速控制路径与通信路径分离。ADC 帧唤醒电机控制任务；UART 和 CAN 任务通过有界的 Embassy 同步原语交换命令和遥测数据。

上位机的真实设备连接使用 v2 PC 桥接、加密 ESP-NOW 链路和电机端 UART 桥接；连接后需要设备身份握手、控制权申请和心跳。浏览器及桌面模拟器用于界面与会话测试，不是包含真实机械动力学的无感控制仿真。当前没有整机板级联调通过的验证记录。

## 仓库结构

| 路径 | 用途 |
|---|---|
| [`software/firmware`](software/firmware) | Rust/Embassy STM32G473RC 固件 |
| [`software/foc-sim`](software/foc-sim/README.md) | Rust 主机仿真 M1：有感 FOC 与独立 PMSM 电气/机械模型 |
| [`software/host-app`](software/host-app/README.md) | Vue + Tauri 上位机；监控、参数管理、控制、自整定入口与录制导出 |
| [`software/esp32-pc-bridge`](software/esp32-pc-bridge/README.md) | 原生 ESP-IDF / ESP32-C3 串口与 ESP-NOW 桥接；替代旧 PlatformIO 工程 |
| [`software/foc-wire`](software/foc-wire) | 固件与上位机共享的 `no_std` v2 帧协议、CRC 与控制权租约 |
| [`hardware/foc-drive/FOC2.kicad_pro`](hardware/foc-drive/FOC2.kicad_pro) | 主驱动板 KiCad 工程 |
| [`hardware/foc-drive/FOC2.kicad_sch`](hardware/foc-drive/FOC2.kicad_sch) | 主驱动板原理图 |
| [`hardware/foc-drive/FOC2.kicad_pcb`](hardware/foc-drive/FOC2.kicad_pcb) | 主驱动板 PCB 布局 |
| [`hardware/foc-expansion/foc-ex.kicad_pro`](hardware/foc-expansion/foc-ex.kicad_pro) | 扩展板 KiCad 工程 |
| [`hardware/foc-expansion/foc-ex.kicad_sch`](hardware/foc-expansion/foc-ex.kicad_sch) | 扩展板原理图 |
| [`hardware/foc-expansion/foc-ex.kicad_pcb`](hardware/foc-expansion/foc-ex.kicad_pcb) | 扩展板 PCB 布局 |
| [`foc/foc.ioc`](foc/foc.ioc) | STM32G473 CubeMX 参考配置；不是运行时固件的唯一依据 |

生成的生产文件、编辑器状态、备份文件和固件二进制文件不属于设计源文件。

## 构建和测试

以下命令均从 `software/firmware` 目录执行。由于固件的默认 Cargo 目标是 `thumbv7em-none-eabihf`，主机测试必须显式指定主机目标。

### 主机测试和 lint

```bash
cargo fmt -- --check
cargo test --target x86_64-pc-windows-msvc
cargo clippy --target x86_64-pc-windows-msvc --test fault_protection --test fault_recovery_and_diagnostics -- -D warnings
```

故障诊断集成测试位于 `software/firmware/tests/`，会使用主机仿真的 ADC 帧和转子采样，不会驱动真实 PWM 或功率级。

### Encoder 固件

```bash
cargo build --bin foc-firmware
```

### Hall 固件

```bash
cargo build --release --bin foc-firmware \
  --no-default-features --features sensor-hall
```

固件 `.cargo/config.toml` 配置了 `thumbv7em-none-eabihf`、`link.x`、`defmt.x` 以及针对 STM32G473RC 的 `probe-rs` 烧录运行器。烧录需要正确连接且获得授权的调试探针；本文档不会执行烧录操作。

## 软件仿真计划

[无感 FOC 软件仿真实施方案](docs/sensorless-simulation-plan.md) 定义了独立 Rust 电机模型、现有固件闭环接入、非理想因素、旁路观测器及无感接管的阶段和验收标准。[主机仿真 M1](software/foc-sim/README.md) 已实现有感物理闭环基线和使用实际转子动力学的自整定参数验证，M2–M5 尚未实施；当前上位机模拟器和自整定流程测试不代表完整的无感物理仿真。

## 硬件概要

主驱动设计基于以下器件和目标：

- STM32G473RC，170 MHz Cortex-M4F 电机控制 MCU。
- 三个 UCC27211 半桥栅极驱动器。
- 六个 100 V 级 N 沟道 MOSFET 位置，组成三相桥。
- 三个 INA240A2 双向电流采样放大器。
- 三个 0.5 mΩ、带 Kelvin 引线的分流电阻。
- 面向 2S–6S 电池的母线设计目标，约 5.5–25.2 V。
- VBUS 分压采样和 TMP235 模拟温度传感器。
- USART3、FDCAN1、SWD、编码器、Hall 和扩展接口。

器件额定值、热限制、自举电路尺寸、开关损耗和电流能力在实际装配电路板完成测量前都只是工程目标。详细计算和待解决问题见开发机上的本地设计说明；该文件有意不纳入共享仓库。

## 验证状态和限制

软件构建和主机测试覆盖了当前实现，但不能证明功率级运行安全。在加电连接电机之前：

1. 检查已装配电路板，确认器件安装、极性、间距、接地和 Kelvin 电流路径正确。
2. 在功率级未上电时，检查全部六路 PWM 波形、互补极性、空闲行为、MOE 关断和实测死区时间。
3. 使用低电压限流电源，验证 ADC 偏置、电流极性/比例、VBUS 比例、温度换算、转子方向和电角度零点对齐。
4. 通过受控故障注入逐项执行软件保护测试。
5. 根据 10 µs PWM 周期测量控制环最坏执行时间。
6. 在逐步增加负载的过程中测量栅极驱动器、MOSFET、分流电阻和电路板温度。
7. 在目标物理接线下确认 UART 和 CAN 行为。

因此，100 kHz 只是配置的运行目标，并不代表已证明装配后的硬件可以长期连续运行在该频率。如果时序、开关损耗、EMI、自举刷新或热测试结果不可接受，应降低集中配置中的 PWM 频率并重新进行全部验证。

## 许可证和贡献状态

固件 crate 声明采用 `MIT OR Apache-2.0` 许可证，仓库根目录的 [`LICENSE`](LICENSE) 为 MIT 许可证。本项目目前仍处于积极的工程开发阶段；在将改动视为可发布版本之前，应结合硬件设计进行审查，并在目标电路板上完成验证。

## KiCad design hardware/foc-drive/FOC2.kicad_pcb

Parts:
C1, C2, C8, C9, C10, C11, C16, C17, C18, C24, C27, C33, C34, C40, C42: 4.7uF; C_0603_1608Metric
C3, C4, C5, C6, C7, C12, C13, C14, C15, C19, C20, C29, C31, C35, C44, C45: 100nF; C_0603_1608Metric
C21, C22, C23, C25, C26: 22uF; C_1210_3225Metric
C28: 47nF; C_0603_1608Metric
C30, C32: 10nF; C_0603_1608Metric
C36, C37, C38, C39, C41, C43: 100nf; C_0603_1608Metric
D1: SM712; SOT-23
D2: MBR0540; D_SOD-123
D3: LED; LED_0603_1608Metric
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_ISO7380_Pad
H5: IN+; MountingHole_3.2mm_M3_ISO7380_Pad
H6: IN-; MountingHole_3.2mm_M3_ISO7380_Pad
H7: A; MountingHole_3.2mm_M3_ISO7380_Pad
H8: B; MountingHole_3.2mm_M3_ISO7380_Pad
H9: C; MountingHole_3.2mm_M3_ISO7380_Pad
J1: Conn_02x12_Odd_Even; PinHeader_2x12_P2.54mm_Vertical
L1: ACM2012-900-2P; ACM2012-900-2P-T001
L2: 10uH; L_Chilisin_BMRA00040420
L3: 4.7uH; L_Chilisin_BMRA00040420
Q1, Q2, Q3, Q4, Q5, Q6: Q_NMOS_SGD; VSONP-8-1EP_5x6_P1.27mm
R1, R2, R5, R6, R10, R11, R17, R18, R30, R31, R32, R33, R34, R35, R36, R37, R38: 10; R_0603_1608Metric
R3, R4, R13, R14, R22, R23, R27, R41: 10k; R_0603_1608Metric
R7, R15, R24: 0.0005; R_2512_6332Metric
R8, R9: 60R; R_0603_1608Metric
R12: 4.99K; R_0603_1608Metric
R16, R21, R25, R39: 100K; R_0603_1608Metric
R19: 71.5K; R_0603_1608Metric
R20, R28, R40: 10K; R_0603_1608Metric
R26: 13.7K; R_0603_1608Metric
R29: 22; R_0603_1608Metric
U1, U2, U6: INA240A2PW; TSSOP-8_4.4x3mm_P0.65mm
U3, U4, U5: UCC27211D; SOIC-8_3.9x4.9mm_P1.27mm; PARTREV F
U7: ME6211C33M5; SOT-23-5
U8: TCAN1044A-Q1; HVSON-8-1EP_3x3mm_P0.65mm_EP1.6x2.4mm
U9: TPS61170; WSON-6-1EP_2x2mm_P0.65mm_EP1x1.6mm_ThermalVias
U10: SY8303; TSOT-23-8
U11: TMP235A2DBZR; SOT-23
U12: STM32G473RCTx; LQFP-64_10x10mm_P0.5mm
Y1: ASCO; Crystal_SMD_2016-4Pin_2.0x1.6mm

Connections:
+3.3V: C1.2, C2.2, C6.2, C7.2, C8.2, C12.2, C17.2, C19.1, C24.2, C35.1, C36.2, C37.2, C38.2, C39.2, C40.2, C41.1, C42.2, C43.1, D3.2 (A), J1.23, R28.1, R41.1, U1.5 (V+), U1.7 (REF1), U2.5 (V+), U2.7 (REF1), U6.5 (V+), U6.7 (REF1), U7.5 (V_{OUT}), U8.5 (NC，Vio), U11.1 (VDD), U12.1 (VBAT), U12.16 (VDD), U12.28 (VREF+), U12.29 (VDDA), U12.32 (VDD), U12.48 (VDD), U12.64 (VDD), Y1.4 (VDD)
+5V: C16.2, C18.2, C20.1, C27.2, C29.2, J1.24, L2.1, L3.2, R25.2, U7.1 (V_{IN}), U7.3 (CE), U8.3 (Vcc), U9.5 (CTRL), U9.6 (VIN)
+10V: C9.2, C10.2, C11.2, C13.2, C14.2, C15.2, C33.2, C34.2, D2.1 (K), R19.2, U3.1 (VDD), U4.1 (VDD), U5.1 (VDD)
/CANH: D1.2 (A2), J1.1, L1.3, R8.1
/CANL: D1.1 (A1), J1.3, L1.4, R9.2
/ENC_A: J1.19, U12.57 (PB4)
/ENC_B: J1.21, U12.58 (PB5)
/ENC_CS: J1.2, U12.41 (PC9)
/FDCAN_RX: R6.1, U12.45 (PA11)
/FDCAN_TX: R5.1, U12.46 (PA12)
/HALL_U: J1.12, U12.38 (PC6)
/HALL_V: J1.14, U12.39 (PC7)
/HALL_W: J1.16, U12.40 (PC8)
/HIN_1: R33.1, U3.5 (HI)
/HIN_2: R34.1, U4.5 (HI)
/HIN_3: R35.1, U5.5 (HI)
/Ialpha: U1.8, U12.12 (PA0)
/Ibeta: U6.8, U12.13 (PA1)
/Igamma: U2.8, U12.24 (PB0)
/LIN_1: R36.1, U3.6 (LI)
/LIN_2: R37.1, U4.6 (LI)
/LIN_3: R38.1, U5.6 (LI)
/M1_GH_A: R2.1, U3.3 (HO)
/M1_GH_B: R10.1, U4.3 (HO)
/M1_GH_C: R17.1, U5.3 (HO)
/M1_GL_A: R1.1, U3.8 (LO)
/M1_GL_B: R11.1, U4.8 (LO)
/M1_GL_C: R18.1, U5.8 (LO)
/SAMPLE1+: Q2.1 (S), R4.2, R7.1, U1.2 (+)
/SAMPLE2+: Q4.1 (S), R14.2, R15.1, U6.2 (+)
/SAMPLE3+: Q6.1 (S), R23.2, R24.1, U2.2 (+)
/SPI_MISO: J1.6, R31.2
/SPI_MOSI: J1.8, R32.2
/SPI_SCK: J1.4, R30.2
/SW1: D2.2 (A), L2.2, U9.4 (SW)
/SW2: C32.1, L3.1, U10.6 (LX)
/SWCLK: J1.7, U12.50 (PA14)
/SWDIO: J1.9, U12.49 (PA13)
/TEMP: U11.2 (VOUT), U12.17 (PA3)
/TIM1_BKIN: J1.20, U12.20 (PA6)
/T_NRST: C45.1, R41.2, U12.7 (PG10)
/UART_RX: J1.15, U12.33 (PB11)
/UART_TX: J1.13, U12.30 (PB10)
/UDC_AD: C44.2, R39.2, R40.2, U12.14 (PA2)
/VS1: C3.1, H7.1, Q1.1 (S), Q2.3 (D), R3.2, U3.4 (HS)
/VS2: C4.1, H8.1, Q3.1 (S), Q4.3 (D), R13.2, U4.4 (HS)
/VS3: C5.1, H9.1, Q5.1 (S), Q6.3 (D), R22.2, U5.4 (HS)
GND: C1.1, C2.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.2, C20.2, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.2, C29.1, C30.1, C31.1, C33.1, C34.1, C35.2, C36.1, C37.1, C38.1, C39.1, C40.1, C41.2, C42.1, C43.2, C44.1, C45.2, D1.3 (common), H6.1, J1.5, J1.10, J1.11, J1.17, J1.18, J1.22, R7.2, R15.2, R20.1, R21.1, R24.2, R26.1, R27.1, R40.1, U1.1 (GND), U1.3 (-), U1.4 (GND), U1.6 (REF2), U2.1 (GND), U2.3 (-), U2.4 (GND), U2.6 (REF2), U3.7 (VSS), U4.7 (VSS), U5.7 (VSS), U6.1 (GND), U6.3 (-), U6.4 (GND), U6.6 (REF2), U7.2 (V_{SS}), U8.2 (GND), U8.8 (STB), U8.EP, U9.3 (GND), U9.7 (EP), U10.3 (GND), U10.4 (GND), U11.3 (GND), U12.15 (VSS), U12.27 (VSSA), U12.31 (VSS), U12.47 (VSS), U12.63 (VSS), Y1.2 (GND)
unnamed: C28.1, R8.2, R9.1
unnamed: C30.2, R12.1
unnamed: D3.1 (K), R27.2
unnamed: Q1.2 (G), R2.2, R3.1
unnamed: Q2.2 (G), R1.2, R4.1
unnamed: Q3.2 (G), R10.2, R13.1
unnamed: Q4.2 (G), R11.2, R14.1
unnamed: Q5.2 (G), R17.2, R22.1
unnamed: Q6.2 (G), R18.2, R23.1
unnamed: C3.2, U3.2 (HB)
unnamed: C4.2, U4.2 (HB)
unnamed: C5.2, U5.2 (HB)
unnamed: L1.1, U8.7 (CAN_H)
unnamed: L1.2, U8.6 (CAN_L)
unnamed: R6.2, U8.4 (RXD)
unnamed: R5.2, U8.1 (TXD)
unnamed: R12.2, U9.2 (COMP)
unnamed: R19.1, R20.2, U9.1 (FB)
unnamed: C32.2, U10.7 (BS)
unnamed: R16.1, U10.8 (EN)
unnamed: R25.1, R26.2, U10.1 (FB)
unnamed: R21.2, U10.2 (FS)
unnamed: R33.2, U12.42 (PA8)
unnamed: R34.2, U12.43 (PA9)
unnamed: R35.2, U12.44 (PA10)
unnamed: R36.2, U12.35 (PB13)
unnamed: R37.2, U12.36 (PB14)
unnamed: R38.2, U12.37 (PB15)
unnamed: R30.1, U12.52 (PC10)
unnamed: R31.1, U12.53 (PC11)
unnamed: R32.1, U12.54 (PC12)
unnamed: R29.1, U12.5 (PF0)
unnamed: R29.2, Y1.3 (OUT)
unnamed: R28.2, Y1.1 (Tri-State)
VDC: C21.2, C22.2, C23.2, C25.2, C26.2, C31.2, H5.1, Q1.3 (D), Q3.3 (D), Q5.3 (D), R16.2, R39.1, U10.5 (IN)

Notes on the sheet:
MCU
终端电阻一条总线只接两个
电压检测
主电源
通信接口
动力部分
CAN
电流采样
栅极控制器

Board: 4 copper layers, 50.0 x 70.0 mm, 121 parts (0 on the bottom side), 83 nets.

## KiCad design hardware/foc-expansion/foc-ex.kicad_pcb

Board: 2 copper layers, 50.0 x 70.0 mm, 16 parts (2 on the bottom side), 3 nets, no tracks yet.

Parts:
C1, C2, C4, C6: C_Small; CP_Radial_D6.3mm_P2.50mm
H1: IN+; MountingHole_3.2mm_M3_ISO7380_Pad
H1#2: IN+
H2, H2#2: IN-; MountingHole_3.2mm_M3_ISO7380_Pad
H4: MountingHole_Pad; MountingHole_3.2mm_M3_ISO7380_Pad
J1: Conn_02x12_Odd_Even; PinHeader_2x12_P2.54mm_Vertical
J2: Conn_01x02; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SW1, SW2, SW3, SW4: SW_Push; SW_Push_SPST_NO_Alps_SKRK
U1: ESP32-S3-WROOM-1

Connections:
+3.3V: J1.23, U1.2 (3V3)
GND: C1.2, C2.2, C4.2, C6.2, H2.1, H2#2.1, J1.5, J1.10, J1.11, J1.17, J1.18, J1.22, U1.1 (GND), U1.40 (GND), U1.41 (GND)
VDC: C1.1, C2.1, C4.1, C6.1, H1.1, H1#2.1

## KiCad design hardware/FOC2.kicad_pcb

Board: 2 copper layers, 108 parts (0 on the bottom side), 55 nets, no tracks yet.

Parts:
C1, C16: 470uf; CP_Radial_D10.0mm_P5.00mm
C5, C8, C22, C23, C24, C25, C26, C36, C38: 10uf; C_0603_1608Metric
C6, C18, C21, C27, C28, C29, C31, C32, C34, C35, C37, C39: 100nf; C_0603_1608Metric
C7: 22nf; C_0603_1608Metric
C17: 47uf; C_1812_4532Metric
C19: 91pf; C_0603_1608Metric
C20: 1.8nf; C_0603_1608Metric
C33: 0.1u; C_0603_1608Metric
D2, D10, D11: fr107; D_SOD-123
D3: type="D" model="ss34" lib=""; D_SMA
D4, D5, D6, D7, D8, D9: 1N4148; D_SOD-123
D12: ZMM3v3; Nexperia_CFP3_SOD-123W
D13: LED; LED_0603_1608Metric
H1, H2, H3, H4, H4#2, H4#3, H4#4, H4#5, H4#6: MountingHole_Pad; MountingHole_2.2mm_M2_DIN965_Pad
H101: IN+; MountingHole_3.2mm_M3_ISO7380_Pad
H102: IN-; MountingHole_3.2mm_M3_ISO7380_Pad
J1: Conn_01x03; AMASS_MR30PW-FB_1x03_P3.50mm_Horizontal
J2: Conn_01x02; Molex_KK-254_AE-6410-02A_1x02_P2.54mm_Vertical
J4: Conn_01x02; AMASS_XT30PW-F_1x02_P2.50mm_Horizontal
J6, J9: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
J8: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
L1: 22uH; L_Abracon_ASPI-0630LR
Q1, Q2, Q3, Q4, Q5, Q6, Q6#2, Q6#3, Q6#4, Q6#5, Q6#6, Q6#7: Q_NMOS_SGD; VSONP-8-1EP_5x6_P1.27mm
R1, R2, R4, R5, R7, R8: 2.2; R_0603_1608Metric
R3, R6, R9: 0.001; R_2512_6332Metric
R10, R11, R12, R13, R14, R20, R22, R23, R25, R26, R27, R28, R29: 10k; R_0603_1608Metric
R15: 71.5k; R_0603_1608Metric
R16: 11k; R_0603_1608Metric
R17: 18.7k; R_0603_1608Metric
R18: 226k; R_0603_1608Metric
R19: 1k; R_0603_1608Metric
R21: 120; R_0603_1608Metric
R24: 62k; R_0603_1608Metric
U1: LM321; SOT-23-5
U3: STM32G431CBUx; QFN-48-1EP_7x7mm_P0.5mm_EP5.6x5.6mm
U4: EG2133; TSSOP-20_4.4x6.5mm_P0.65mm
U5, U6: INA199xxDCK; SOT-363_SC-70-6
U7: TPS54360DDA; TI_SO-PowerPAD-8_ThermalVias
U8: TJA1044GTK/3Z; HVSON-8-1EP_3x3mm_P0.65mm_EP1.6x2.4mm
U9: LP5907MFX-3.3; SOT-23-5
U10: REF3033; SOT-23

Connections:
+1.65V: R19.1, U5.1 (REF), U6.1 (REF)
+3.3V: C31.2, C32.2, C34.2, C35.2, C36.1, C37.1, C38.1, C39.1, R25.1, U3.1 (VBAT), U3.21 (VDDA), U3.22 (PB10), U3.23 (VDD), U3.35 (VDD), U3.48 (VDD)
+3V3: C7.1, C8.1, C26.1, C27.1, C28.1, C29.1, R13.2, U1.5 (V+), U5.3 (V+), U6.3 (V+), U9.5 (OUT)
+5V: C5.1, C6.1, C17.2, C21.1, C22.1, D2.2 (A), D10.2 (A), D11.2 (A), D13.2 (A), L1.2, R15.2, U4.7 (VCC), U8.3 (VCC), U9.1 (IN), U9.3 (EN), U10.1 (IN)
/CANH: J2.1, R21.1, U8.7 (CANH)
/CANL: J2.2, R21.2, U8.6 (CANL)
/CAN_STB: R12.2, U8.8 (STB)
/FDCAN_RX: U3.34 (PA12), U8.4 (RXD)
/FDCAN_TX: U3.33 (PA11), U8.1 (TXD)
/HIN_1: U3.30 (PA8), U4.1 (HIN1), U4.4 (LIN1)
/HIN_2: U3.31 (PA9), U4.2 (HIN2), U4.5 (LIN2)
/HIN_3: U3.32 (PA10), U4.3 (HIN3), U4.6 (LIN3)
/Ialpha: U3.8 (PA0), U5.6
/Ibeta: U3.9 (PA1), U6.6
/M1_GH_A: D4.1 (K), R1.1, U4.19 (HO1)
/M1_GH_B: D6.1 (K), R4.1, U4.16 (HO2)
/M1_GH_C: D8.1 (K), R7.1, U4.13 (HO3)
/M1_GL_A: D5.1 (K), R2.1, U4.11 (LO1)
/M1_GL_B: D7.1 (K), R5.1, U4.10 (LO2)
/M1_GL_C: D9.1 (K), R8.1, U4.9 (LO3)
/M1_SL_A: Q2.1 (S), R3.1, R11.2
/M1_SL_B: Q4.1 (S), R6.1, R29.2, U5.4 (+)
/M1_SL_C: Q6.1 (S), Q6#2.1 (S), Q6#3.1 (S), Q6#4.1 (S), Q6#5.1 (S), Q6#6.1 (S), Q6#7.1 (S), R9.1, R28.2, U6.4 (+)
/SWCLK: J6.2, U3.37 (PA14)
/SWDIO: J6.3, U3.36 (PA13)
/T_NRST: C33.1, J6.1, R25.2, U3.7 (PG10)
/UART_RX: J8.2, U3.45 (PB7)
/UART_TX: J8.1, U3.44 (PB6)
/UDC_AD: D12.1 (K), R23.2, R24.1, U3.10 (PA2)
/VREF: U3.20 (VREF+), U10.2 (OUT)
/VS1: C24.2, J1.1, Q1.1 (S), Q2.3 (D), R10.2, U4.18 (VS1)
/VS2: C23.2, J1.2, Q3.1 (S), Q4.3 (D), R22.2, U4.15 (VS2)
/VS3: C25.2, J1.3, Q5.1 (S), Q6.3 (D), Q6#2.3 (D), Q6#3.3 (D), Q6#4.3 (D), Q6#5.3 (D), Q6#6.3 (D), Q6#7.3 (D), R27.2, U4.12 (VS3)
Earth: H1.1, H2.1, H3.1, H4.1, H4#2.1, H4#3.1, H4#4.1, H4#5.1, H4#6.1
GND: C1.2, C5.2, C6.2, C7.2, C8.2, C16.2, C17.1, C19.1, C20.1, C21.2, C22.2, C26.2, C27.2, C28.2, C29.2, C31.1, C32.1, C33.2, C34.1, C35.1, C36.2, C37.2, C38.2, C39.2, D3.1 (A), D12.2 (A), H102.1, J4.1, J6.4, J8.3, R3.2, R6.2, R9.2, R12.1, R14.1, R16.1, R18.1, R20.1, R23.1, R26.1, U1.2 (V-), U3.49 (VSS), U4.8 (GND), U5.2 (GND), U5.5 (-), U6.2 (GND), U6.5 (-), U7.7 (GND), U7.9 (GNDPAD), U8.2 (GND), U8.9, U9.2 (GND), U10.3 (GND)
unnamed: C20.2, R17.1
unnamed: C23.1, D2.1 (K), U4.17 (VB2)
unnamed: C18.1, D3.2 (K), L1.1, U7.8 (SW)
unnamed: D4.2 (A), Q1.2 (G), R1.2, R10.1
unnamed: D5.2 (A), Q2.2 (G), R2.2, R11.1
unnamed: D6.2 (A), Q3.2 (G), R4.2, R22.1
unnamed: D7.2 (A), Q4.2 (G), R5.2, R29.1
unnamed: D8.2 (A), Q5.2 (G), R7.2, R27.1
unnamed: D9.2 (A), Q6.2 (G), Q6#2.2 (G), Q6#3.2 (G), Q6#4.2 (G), Q6#5.2 (G), Q6#6.2 (G), Q6#7.2 (G), R8.2, R28.1
unnamed: C25.1, D10.1 (K), U4.14 (VB3)
unnamed: C24.1, D11.1 (K), U4.20 (VB1)
unnamed: D13.1 (K), R26.2
unnamed: R13.1, R14.2, U1.1 (+)
unnamed: R19.2, U1.3 (-), U1.4
unnamed: R20.2, U3.46 (PB8)
unnamed: C18.2, U7.1 (BOOT)
unnamed: C19.2, R17.2, U7.6 (COMP)
unnamed: R15.1, R16.2, U7.5 (FB)
unnamed: R18.2, U7.4 (RT/CLK)
VDC: C1.1, C16.1, H101.1, J4.2, Q1.3 (D), Q3.3 (D), Q5.3 (D), R24.2, U7.2 (VIN)

## Code that names these connections

File software/firmware/src/main.rs (part):

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        interrupt::FDCAN1_IT1.set_priority(Priority::P6);
        interrupt::RNG.set_priority(Priority::P6);

        let _software_break_only = Input::new(p.PA6, Pull::Down);
        let pwm = Tim1PwmBridge::new(
            p.TIM1, p.PA8, p.PB13, p.PA9, p.PB14, p.PA10, p.PB15,
        );
        init_injected_adcs(InjectedAdcResources {
            adc1: p.ADC1,
            adc2: p.ADC2,
            adc3: p.ADC3,
            phase_a: p.PA0,
            phase_b: p.PA1,
            phase_c: p.PB0,
            bus_voltage: p.PA2,
            ntc: p.PA3,
        });

        #[cfg(all(feature = "sensor-encoder", not(feature = "sensor-hall")))]
        let sensor = EncoderSensor::new(
            p.TIM3,
            p.PB4,
            p.PB5,
            working_parameters.encoder_cpr,
        );
        #[cfg(all(feature = "sensor-hall", not(feature = "sensor-encoder")))]
        let sensor =
            HallSensor::new(p.TIM3, p.PC6, p.PC7, p.PC8, foc_config.pole_pairs);

        let mut uart_config = UartConfig::default();
        uart_config.baudrate = 115_200;
        let uart = Uart::new(
            p.USART3,
            p.PB11,
            p.PB10,
            p.DMA1_CH1,
            p.DMA1_CH2,
            BoardIrqs,
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        .unwrap();

        let mut can_configurator =
            can::CanConfigurator::new(p.FDCAN1, p.PA11, p.PA12, BoardIrqs);
        let can_config = can_configurator
            .config()
            .set_global_filter(can::config::GlobalFilter::reject_all());
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
File foc/foc.ioc (part):

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Mcu.Name=STM32G473R(B-C-E)Tx
Mcu.Package=LQFP64
Mcu.UserName=STM32G473RCTx
PA0.Mode=IN1-Single-Ended
PA0.Signal=ADC1_IN1
PA10.Signal=S_TIM1_CH3
PA11.Mode=FDCAN_Activate
PA11.Signal=FDCAN1_RX
PA12.Mode=FDCAN_Activate
PA12.Signal=FDCAN1_TX
PA2.Mode=IN3-Single-Ended
PA2.Signal=ADC1_IN3
PA3.Mode=IN4-Single-Ended
PA3.Signal=ADC1_IN4
PA8.Signal=S_TIM1_CH1
PA9.Signal=S_TIM1_CH2
PB0.Mode=IN12-Single-Ended
PB0.Signal=ADC3_IN12
PB10.Mode=Asynchronous
PB10.Signal=USART3_TX
PB11.Mode=Asynchronous
PB11.Signal=USART3_RX
PB13.Mode=PWM Generation1 CH1 CH1N
PB13.Signal=TIM1_CH1N
PB14.Mode=PWM Generation2 CH2 CH2N
PB14.Signal=TIM1_CH2N
PB15.Mode=PWM Generation3 CH3 CH3N
PB15.Signal=TIM1_CH3N
PB4.Signal=S_TIM3_CH1
PB5.Signal=S_TIM3_CH2
PC0.Signal=ADC2_IN6
PC10.Mode=Full_Duplex_Master
PC10.Signal=SPI3_SCK
PC11.Mode=Full_Duplex_Master
PC11.Signal=SPI3_MISO
PC12.Mode=Full_Duplex_Master
PC12.Signal=SPI3_MOSI
RCC.HSE_VALUE=8000000
RCC.SYSCLKFreq_VALUE=16000000
board=custom

File software/firmware/src/bsp_hardware.rs (part):

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impl<'d> Tim1PwmBridge<'d> {
    pub fn new(
        tim: Peri<'d, peripherals::TIM1>,
        phase_a_high: Peri<'d, peripherals::PA8>,
        phase_a_low: Peri<'d, peripherals::PB13>,
        phase_b_high: Peri<'d, peripherals::PA9>,
        phase_b_low: Peri<'d, peripherals::PB14>,
        phase_c_high: Peri<'d, peripherals::PA10>,
        phase_c_low: Peri<'d, peripherals::PB15>,
    ) -> Self {
        let mut pwm = ComplementaryPwm::new(
            tim,
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static ADC_HANDLES: CriticalSectionMutex<RefCell<Option<AdcHandles>>> =
    CriticalSectionMutex::new(RefCell::new(None));

static PHASE_A_PIN: StaticCell<Peri<'static, peripherals::PA0>> =
    StaticCell::new();
static PHASE_B_PIN: StaticCell<Peri<'static, peripherals::PA1>> =
    StaticCell::new();
static PHASE_C_PIN: StaticCell<Peri<'static, peripherals::PB0>> =
    StaticCell::new();
static BUS_VOLTAGE_PIN: StaticCell<Peri<'static, peripherals::PA2>> =
    StaticCell::new();
static NTC_PIN: StaticCell<Peri<'static, peripherals::PA3>> = StaticCell::new();

pub struct InjectedAdcResources {
    pub adc1: Peri<'static, peripherals::ADC1>,
    pub adc2: Peri<'static, peripherals::ADC2>,
    pub adc3: Peri<'static, peripherals::ADC3>,
    pub phase_a: Peri<'static, peripherals::PA0>,
    pub phase_b: Peri<'static, peripherals::PA1>,
    pub phase_c: Peri<'static, peripherals::PB0>,
    pub bus_voltage: Peri<'static, peripherals::PA2>,
    pub ntc: Peri<'static, peripherals::PA3>,
}

pub fn init_injected_adcs(resources: InjectedAdcResources) {
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impl<'d> EncoderSensor<'d> {
    pub fn new(
        tim: Peri<'d, peripherals::TIM3>,
        channel_a: Peri<'d, peripherals::PB4>,
        channel_b: Peri<'d, peripherals::PB5>,
        counts_per_revolution: u16,
    ) -> Self {
        let counts_per_revolution = counts_per_revolution.max(2);
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impl<'d> HallSensor<'d> {
    pub fn new(
        tim: Peri<'d, peripherals::TIM3>,
        hall_u: Peri<'d, peripherals::PC6>,
        hall_v: Peri<'d, peripherals::PC7>,
        hall_w: Peri<'d, peripherals::PC8>,
        pole_pairs: u8,
    ) -> Self {
        let ch1 = CaptureInput::from_pin(hall_u, Pull::Up).unwrap();
        let ch2 = CaptureInput::from_pin(hall_v, Pull::Up).unwrap();
        let ch3 = CaptureInput::from_pin(hall_w, Pull::Up).unwrap();
        let mut capture = InputCapture::new(
            tim,
            Some(ch1),
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
File software/Target/Target.ioc (part):

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Mcu.Name=STM32G431C(6-8-B)Ux
Mcu.Package=UFQFPN48
Mcu.UserName=STM32G431CBUx
PA0.Mode=IN1-Single-Ended
PA0.Signal=ADC2_IN1
PA1.Mode=IN2-Single-Ended
PA1.Signal=ADC2_IN2
PA10.Signal=S_TIM1_CH3
PA11.Mode=FDCAN_Activate
PA11.Signal=FDCAN1_RX
PA12.Mode=FDCAN_Activate
PA12.Signal=FDCAN1_TX
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PA2.Mode=IN3-Single-Ended
PA2.Signal=ADC1_IN3
PA5.Mode=Full_Duplex_Master
PA5.Signal=SPI1_SCK
PA6.Mode=Full_Duplex_Master
PA6.Signal=SPI1_MISO
PA7.Mode=Full_Duplex_Master
PA7.Signal=SPI1_MOSI
PA8.Signal=S_TIM1_CH1
PA9.Signal=S_TIM1_CH2
PB0.Signal=GPIO_Output
PB13.Mode=PWM Generation1 CH1 CH1N
PB13.Signal=TIM1_CH1N
PB14.Mode=PWM Generation2 CH2 CH2N
PB14.Signal=TIM1_CH2N
PB15.Mode=PWM Generation3 CH3 CH3N
PB15.Signal=TIM1_CH3N
PB6.Mode=Asynchronous
PB6.Signal=USART1_TX
PB7.Mode=Asynchronous
PB7.Signal=USART1_RX
PC4.Signal=GPIO_Output
RCC.HSE_VALUE=8000000
RCC.SYSCLKFreq_VALUE=170000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

## Commit log (part)

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2024-01-09 修改PCB和电路图
2025-04-21 工程重构
2025-05-15 添加驱动设计
